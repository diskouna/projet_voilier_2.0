# Keil uVision project Projet_Voilier.uvprojx, settings and files
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet_Voilier
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Mes_Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ../Mes_Drivers/: MyGPIO.c MyTimer.c MyUSART.c Lib_Com_Periph_2022.lib
    ./: main.c MyMoteur.c MyServo.c MyComm.c MyRTC.c MyIMU.c bordage_automatique.c girouette.c MYADC.c tension_batteries.c MyTest.c
  group include
    ./: MyMoteur.h MyServo.h MyComm.h MyRTC.h MyIMU.h MyVoilier.h BORDAGE_AUTOMMATIQUE.h GIROUETTE.h MYADC.h TENSION_BATTERIES.h MyTest.h
target Simule (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Projet_Voilier
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Mes_Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
